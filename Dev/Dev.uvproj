# Keil uVision project Dev.uvproj, settings and files
target LPC2148 (ARM-ADS)
  device: LPC2148 NXP
  cpu: IRAM(0x40000000-0x40007FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: Dev +hex
  c flags: OneElfS=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x40000000 size 0x8000
  scatter file: .\Objects\Dev.sct
  group Development
    ./: Startup.s main.cpp sampleProgram.cpp uart.cpp adc.cpp spi.cpp pll.cpp interrupt.cpp delay.cpp pin.cpp ILI9229.cpp spi1.cpp i2c.cpp INFO_TODO.txt process.cpp adc.h dac.cpp
