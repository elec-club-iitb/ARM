# Keil uVision project tiva_Test.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: ARMCM4 ARM
  pack: ARM.CMSIS.4.3.0
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M4") CLOCK(12000000) ESEL ELITTLE
  output: tiva_Test
  c flags: Optim=1 OneElfS=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
software components: CMSIS:DSP 1.4.5
