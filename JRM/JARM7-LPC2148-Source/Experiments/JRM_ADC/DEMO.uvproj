# Keil uVision project DEMO.uvproj, settings and files
target DEMO (ARM-ADS)
  device: LPC2148 NXP (founded by Philips)
  cpu: IRAM(0x40000000-0x40007FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: DEMO +hex
  c flags: Optim=4
  c include: ..\..\OBJ;..\..\INC
  asm include: ..\..\OBJ;..\..\INC
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x40000000 size 0x8000
  group Startup Code
    ./: Startup.s
  group System Calls
    ./: Retarget.c
  group Source Code
    ./: DEMO.c
  group Library
    ../../OBJ/: LIBs.lib
