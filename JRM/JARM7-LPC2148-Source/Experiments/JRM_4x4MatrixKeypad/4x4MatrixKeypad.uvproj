# Keil uVision project 4x4MatrixKeypad.uvproj, settings and files
target LPC2100 (ARM-ADS)
  device: LPC2148 NXP (founded by Philips)
  cpu: IRAM(0x40000000-0x40007FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: 4x4MatrixKeypad +hex
  c flags: Optim=1
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x40000000 size 0x8000
  group Startup Code
    ./: Startup.s
  group System Calls
    ./: Retarget.c
  group Source Code
    ./: main.c buzzer.c keypad.c lcd.c keypad_isr.c
  group Documentation
    ./: Abstract.txt
