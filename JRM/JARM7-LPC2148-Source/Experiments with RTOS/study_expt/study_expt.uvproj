# Keil uVision project study_expt.uvproj, settings and files
target Flash (ARM-ADS)
  device: LPC2148 NXP (founded by Philips)
  cpu: IRAM(0x40000000-0x40007FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: study_expt +hex
  c flags: Optim=3 wLevel=2
  c include: .;..\BSP;..\uCOS-II\Source;..\uC-CPU;..\uCOS-II\Ports;..\uC-LIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x40000000 size 0x8000
  scatter file: ..\BSP\LPC2148_Flash.scat
  link misc: --entry ResetHndlr
  group APP
    ./: app.c app_cfg.h includes.h os_cfg.h lcd_app.c 8x8.c 64x128GLCD.c lcd_app.h utils.h 64x128GLCD.h adc.c adc.h
  group BSP
    ../BSP/: bsp.h bsp.c vectors.s init.s iolpc2148.h
  group uC-CPU
    ../uC-CPU/: cpu_a.s cpu.h cpu_def.h
  group uC-OS-II/Source
    ../uCOS-II/Source/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
  group uC-OS-II/Port
    ../uCOS-II/Ports/: os_cpu.h os_cpu_a.asm os_cpu_c.c os_dbg.c
  group Scatter
    ../BSP/: LPC2148_Flash.scat
  group lib
    ../uC-LIB/: lib_def.h lib_mem.c lib_mem.h lib_str.c lib_str.h
  group Documentation
    ./: Abstract.txt
